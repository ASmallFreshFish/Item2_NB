# Keil uVision project Project.uvprojx, settings and files
target STM32L1XX_MD(STM32L1xxxBxx) (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L152-EVAL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_STM32L152_EVAL
  c misc: --c99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL;..\..\HARDWARE\usart;..\..\HARDWARE\TIMER;..\..\HARDWARE\BC95;..\..\HARDWARE\LED;..\..\HARDWARE\key;..\..\HARDWARE\delay;..\..\HARDWARE\DHT11;..\..\..\Libraries\CMSIS\Include;..\..\HARDWARE\bus;..\..\Test;..\..\HARDWARE\pressure;..\..\HARDWARE\gesture;..\..\HARDWARE\PAJ7620U2;..\..\HARDWARE\IWDG;..\..\HARDWARE\VL53L0X\core;..\..\HARDWARE\VL53L0X\demo;..\..\HARDWARE\VL53L0X\platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --diag_suppress=L6329
  group User
    ../: main.c stm32l1xx_it.c
    ../../HARDWARE/BC95/: BC95.c
  group StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dbgmcu.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c stm32l1xx_aes_util.c
  group CMSIS
    ../: system_stm32l1xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s startup_stm32l1xx_hd.s startup_stm32l1xx_xl.s
  group HARDWARE
    ../../HARDWARE/usart/: usart.c
    ../../HARDWARE/TIMER/: timer.c
    ../../HARDWARE/LED/: LED.c
    ../../HARDWARE/delay/: delay.c
    ../../HARDWARE/DHT11/: dht11.c
    ../../HARDWARE/key/: key.c
    ../../HARDWARE/bus/: bus.c
    ../../HARDWARE/pressure/: pressure_sensor.c
    ../../HARDWARE/gesture/: gesture.c
    ../../HARDWARE/PAJ7620U2/: paj7620u2.c paj7620u2_iic.c
    ../../HARDWARE/IWDG/: iwdg.c
  group VL53L0X
    ../../HARDWARE/VL53L0X/core/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../../HARDWARE/VL53L0X/demo/: vl53l0x.c vl53l0x_gen.c
    ../../HARDWARE/VL53L0X/platform/: vl53l0x_i2c.c vl53l0x_platform.c
target STM32L1XX_MDP(STM32L1xxxCxx) (ARM-ADS)
  device: STM32L152ZC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L1XX_MDP
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MDP
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
target STM32L1XX_HD(STM32L1xxxDxx) (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L152D-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_HD, USE_STM32L152D_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
target STM32L1XX_XL(STM32L1xxxExx) (ARM-ADS)
  device: STM32L152ZE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L1XX_XL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_XL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
